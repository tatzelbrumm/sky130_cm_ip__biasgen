** sch_path: xschem/sky130_cm_ip__biasgen.sch
**.subckt sky130_cm_ip__biasgen avss avdd Ibin Vpb Vpc Iout[2],Iout[1] dvdd en[2],en[1] poweron
*.iopin avss
*.iopin avdd
*.iopin Ibin
*.iopin Vpb
*.iopin Vpc
*.iopin Iout[2],Iout[1]
*.iopin dvdd
*.iopin en[2],en[1]
*.iopin poweron
xsrc avdd Vpb Vpc Iout[2] Iout[1] Igated avss en[2] en[1] dvdd sky130_cm_sources l={l} w={w} nf={nf}
+ lc={lc} wc={wc} nfc={nfc} lb={lb} wb={wb} nfb={nfb} ln={lnmos} wn={wnmos} nfn={nfnmos}
xpower avdd Vpb Vpc Ibin Igated dvdd poweron avss sky130_cm_poweroff lpt=1 wpt=4 nfpt=1 lnt=1 wnt=2
+ nfnt=1 lpu=1 wpu=2 nfpu=1 lpd=1 wpd=2 nfpd=1
**.ends

* expanding   symbol:  xschem/sky130_cm_sources.sym # of pins=8
** sym_path: xschem/sky130_cm_sources.sym
** sch_path: xschem/sky130_cm_sources.sch
.subckt sky130_cm_sources avdd Vpb Vpc Iout[2] Iout[1] Ibin avss en[2] en[1] dvdd  l=8 w=2 nf=1
+ lc=0.5 wc=2 nfc=1 lb=18 wb=1 nfb=1 lnmos=8 wnmos=2 nfnmos=1
*.iopin avss
*.iopin avdd
*.iopin Ibin
*.iopin Vpb
*.iopin Vpc
*.iopin Iout[2],Iout[1]
*.iopin dvdd
*.iopin en[2],en[1]
XMc3 Vpc Vpc avdd avdd sky130_fd_pr__pfet_g5v0d10v5 L={lb} W={wb} nf={nfb} ad='int(({nfb} + 1)/2) * {wb} / {nfb} * 0.29'
+ as='int(({nfb} + 2)/2) * {wb} / {nfb} * 0.29' pd='2*int(({nfb} + 1)/2) * ({wb} / {nfb} + 0.29)' ps='2*int(({nfb} + 2)/2) * ({wb} / {nfb} + 0.29)'
+ nrd='0.29 / {wb} ' nrs='0.29 / {wb} ' sa=0 sb=0 sd=0 mult=1 m=1
XMn1 Ibin Ibin avss avss sky130_fd_pr__nfet_g5v0d10v5 L={lnmos} W={wnmos} nf={nfnmos} ad='int(({nfnmos} + 1)/2) * {wnmos} / {nfnmos} * 0.29'
+ as='int(({nfnmos} + 2)/2) * {wnmos} / {nfnmos} * 0.29' pd='2*int(({nfnmos} + 1)/2) * ({wnmos} / {nfnmos} + 0.29)'
+ ps='2*int(({nfnmos} + 2)/2) * ({wnmos} / {nfnmos} + 0.29)' nrd='0.29 / {wnmos} ' nrs='0.29 / {wnmos} '
+ sa=0 sb=0 sd=0 mult=1 m=1
XMn2 Vpc Ibin avss avss sky130_fd_pr__nfet_g5v0d10v5 L={lnmos} W={wnmos} nf={nfnmos} ad='int(({nfnmos} + 1)/2) * {wnmos} / {nfnmos} * 0.29'
+ as='int(({nfnmos} + 2)/2) * {wnmos} / {nfnmos} * 0.29' pd='2*int(({nfnmos} + 1)/2) * ({wnmos} / {nfnmos} + 0.29)'
+ ps='2*int(({nfnmos} + 2)/2) * ({wnmos} / {nfnmos} + 0.29)' nrd='0.29 / {wnmos} ' nrs='0.29 / {wnmos} '
+ sa=0 sb=0 sd=0 mult=1 m=1
XMn3 Vpb Ibin avss avss sky130_fd_pr__nfet_g5v0d10v5 L={lnmos} W={wnmos} nf={nfnmos} ad='int(({nfnmos} + 1)/2) * {wnmos} / {nfnmos} * 0.29'
+ as='int(({nfnmos} + 2)/2) * {wnmos} / {nfnmos} * 0.29' pd='2*int(({nfnmos} + 1)/2) * ({wnmos} / {nfnmos} + 0.29)'
+ ps='2*int(({nfnmos} + 2)/2) * ({wnmos} / {nfnmos} + 0.29)' nrd='0.29 / {wnmos} ' nrs='0.29 / {wnmos} '
+ sa=0 sb=0 sd=0 mult=1 m=1
xlvl[2] avdd vgoff[2] dvdd vgon[2] en[2] avss sky130_cm_levelshifter
xlvl[1] avdd vgoff[1] dvdd vgon[1] en[1] avss sky130_cm_levelshifter
x0 avdd avdd Vpb avss Vpc Vpb sky130_cm_sw_psource l={l} w={w} nf={nf} lc={lc} wc={wc} nfc={nfc} lon=.5
+ won=1 nfon=1 loff=.5 woff=1 nfoff=1
xsrc[2] avdd vgoff[2] Vpb vgon[2] Vpc Iout[2] sky130_cm_sw_psource l={l} w={w} nf={nf} lc={lc} wc={wc}
+ nfc={nfc} lon=.5 won=1 nfon=1 loff=.5 woff=1 nfoff=1
xsrc[1] avdd vgoff[1] Vpb vgon[1] Vpc Iout[1] sky130_cm_sw_psource l={l} w={w} nf={nf} lc={lc} wc={wc}
+ nfc={nfc} lon=.5 won=1 nfon=1 loff=.5 woff=1 nfoff=1
.ends


* expanding   symbol:  xschem/sky130_cm_poweroff.sym # of pins=8
** sym_path: xschem/sky130_cm_poweroff.sym
** sch_path: xschem/sky130_cm_poweroff.sch
.subckt sky130_cm_poweroff avdd Vpb Vpc Ibin Ibout dvdd en avss  lpt=1 wpt=4 nfpt=1 lnt=1 wnt=2
+ nfnt=1 lpu=1 wpu=2 nfpu=1 lpd=@1 wpd=2 nfpd=1
*.iopin avss
*.iopin avdd
*.iopin Ibin
*.iopin Vpb
*.iopin Vpc
*.iopin dvdd
*.iopin en
*.iopin Ibout
XMnpd Ibout off avss avss sky130_fd_pr__nfet_g5v0d10v5 L={lpd} W={wpd} nf={nfpd} ad='int(({nfpd} + 1)/2) * {wpd} / {nfpd} * 0.29'
+ as='int(({nfpd} + 2)/2) * {wpd} / {nfpd} * 0.29' pd='2*int(({nfpd} + 1)/2) * ({wpd} / {nfpd} + 0.29)'
+ ps='2*int(({nfpd} + 2)/2) * ({wpd} / {nfpd} + 0.29)' nrd='0.29 / {wpd} ' nrs='0.29 / {wpd} ' sa=0 sb=0
+ sd=0 mult=1 m=1
xlvl avdd on dvdd off en avss sky130_cm_levelshifter
XMpt Ibout off Ibin avdd sky130_fd_pr__pfet_g5v0d10v5 L={lpt} W={wpt} nf={nfpt} ad='int(({nfpt} + 1)/2) * {wpt} / {nfpt} * 0.29'
+ as='int(({nfpt} + 2)/2) * {wpt} / {nfpt} * 0.29' pd='2*int(({nfpt} + 1)/2) * ({wpt} / {nfpt} + 0.29)'
+ ps='2*int(({nfpt} + 2)/2) * ({wpt} / {nfpt} + 0.29)' nrd='0.29 / {wpt} ' nrs='0.29 / {wpt} ' sa=0 sb=0
+ sd=0 mult=1 m=1
XMnt Ibout on Ibin avss sky130_fd_pr__nfet_g5v0d10v5 L={lnt} W={wnt} nf={nfnt} ad='int(({nfnt} + 1)/2) * {wnt} / {nfnt} * 0.29'
+ as='int(({nfnt} + 2)/2) * {wnt} / {nfnt} * 0.29' pd='2*int(({nfnt} + 1)/2) * ({wnt} / {nfnt} + 0.29)'
+ ps='2*int(({nfnt} + 2)/2) * ({wnt} / {nfnt} + 0.29)' nrd='0.29 / {wnt} ' nrs='0.29 / {wnt} ' sa=0 sb=0
+ sd=0 mult=1 m=1
XMpuc Vpc on avdd avdd sky130_fd_pr__pfet_g5v0d10v5 L={lpu} W={wpu} nf={nfpu} ad='int(({nfpu} + 1)/2) * {wpu} / {nfpu} * 0.29'
+ as='int(({nfpu} + 2)/2) * {wpu} / {nfpu} * 0.29' pd='2*int(({nfpu} + 1)/2) * ({wpu} / {nfpu} + 0.29)'
+ ps='2*int(({nfpu} + 2)/2) * ({wpu} / {nfpu} + 0.29)' nrd='0.29 / {wpu} ' nrs='0.29 / {wpu} ' sa=0 sb=0
+ sd=0 mult=1 m=1
XMpub Vpb on avdd avdd sky130_fd_pr__pfet_g5v0d10v5 L={lpu} W={wpu} nf={nfpu} ad='int(({nfpu} + 1)/2) * {wpu} / {nfpu} * 0.29'
+ as='int(({nfpu} + 2)/2) * {wpu} / {nfpu} * 0.29' pd='2*int(({nfpu} + 1)/2) * ({wpu} / {nfpu} + 0.29)'
+ ps='2*int(({nfpu} + 2)/2) * ({wpu} / {nfpu} + 0.29)' nrd='0.29 / {wpu} ' nrs='0.29 / {wpu} ' sa=0 sb=0
+ sd=0 mult=1 m=1
.ends


* expanding   symbol:  xschem/sky130_cm_levelshifter.sym # of pins=6
** sym_path: xschem/sky130_cm_levelshifter.sym
** sch_path: xschem/sky130_cm_levelshifter.sch
.subckt sky130_cm_levelshifter avdd Q dvdd Qb A avss
*.iopin avss
*.iopin avdd
*.iopin A
*.iopin dvdd
*.iopin Qb
*.iopin Q
XMnl1 Q ab avss avss sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=6 nf=1 ad='int((1 + 1)/2) * 6 / 1 * 0.29' as='int((1 + 2)/2) * 6 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (6 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (6 / 1 + 0.29)' nrd='0.29 / 6 ' nrs='0.29 / 6 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XMnl2 Qb abb avss avss sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=6 nf=1 ad='int((1 + 1)/2) * 6 / 1 * 0.29'
+ as='int((1 + 2)/2) * 6 / 1 * 0.29' pd='2*int((1 + 1)/2) * (6 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (6 / 1 + 0.29)'
+ nrd='0.29 / 6 ' nrs='0.29 / 6 ' sa=0 sb=0 sd=0 mult=1 m=1
XMpl1 Q Qb avdd avdd sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XMpl2 Qb Q avdd avdd sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XMn1 ab A avss avss sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XMp1 ab A dvdd dvdd sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XMn2 abb ab avss avss sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XMp2 abb ab dvdd dvdd sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  xschem/sky130_cm_sw_psource.sym # of pins=6
** sym_path: xschem/sky130_cm_sw_psource.sym
** sch_path: xschem/sky130_cm_sw_psource.sch
.subckt sky130_cm_sw_psource avdd offb Vpb onb Vpc Iout  l=8 w=2 nf=1 lc=0.5 wc=2 nfc=1 lon=.5 won=1
+ nfon=1 loff=.5 woff=1 nfoff=1
*.iopin avdd
*.iopin Vpb
*.iopin Vpc
*.iopin Iout
*.iopin offb
*.iopin onb
XMc2 Iout vsw vd avdd sky130_fd_pr__pfet_g5v0d10v5 L={lc} W={wc} nf={nfc} ad='int(({nfc} + 1)/2) * {wc} / {nfc} * 0.29'
+ as='int(({nfc} + 2)/2) * {wc} / {nfc} * 0.29' pd='2*int(({nfc} + 1)/2) * ({wc} / {nfc} + 0.29)' ps='2*int(({nfc} + 2)/2) * ({wc} / {nfc} + 0.29)'
+ nrd='0.29 / {wc} ' nrs='0.29 / {wc} ' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vd Vpb avdd avdd sky130_fd_pr__pfet_g5v0d10v5 L={l} W={w} nf={nf} ad='int(({nf} + 1)/2) * {w} / {nf} * 0.29'
+ as='int(({nf} + 2)/2) * {w} / {nf} * 0.29' pd='2*int(({nf} + 1)/2) * ({w} / {nf} + 0.29)' ps='2*int(({nf} + 2)/2) * ({w} / {nf} + 0.29)'
+ nrd='0.29 / {w} ' nrs='0.29 / {w} ' sa=0 sb=0 sd=0 mult=1 m=1
XMon Vpc onb vsw avdd sky130_fd_pr__pfet_g5v0d10v5 L={lon} W={won} nf={nfon} ad='int(({nfon} + 1)/2) * {won} / {nfon} * 0.29'
+ as='int(({nfon} + 2)/2) * {won} / {nfon} * 0.29' pd='2*int(({nfon} + 1)/2) * ({won} / {nfon} + 0.29)'
+ ps='2*int(({nfon} + 2)/2) * ({won} / {nfon} + 0.29)' nrd='0.29 / {won} ' nrs='0.29 / {won} ' sa=0 sb=0
+ sd=0 mult=1 m=1
XMoff vsw offb avdd avdd sky130_fd_pr__pfet_g5v0d10v5 L={loff} W={woff} nf={nfoff} ad='int(({nfoff} + 1)/2) * {woff} / {nfoff} * 0.29'
+ as='int(({nfoff} + 2)/2) * {woff} / {nfoff} * 0.29' pd='2*int(({nfoff} + 1)/2) * ({woff} / {nfoff} + 0.29)'
+ ps='2*int(({nfoff} + 2)/2) * ({woff} / {nfoff} + 0.29)' nrd='0.29 / {woff} ' nrs='0.29 / {woff} ' sa=0
+ sb=0 sd=0 mult=1 m=1
.ends

.end
